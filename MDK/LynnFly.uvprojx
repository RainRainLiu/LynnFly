# Keil uVision project LynnFly.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LynnFly
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_HD
  c include: ..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\FreeRtos\include;..\FreeRtos\portable\RVDS\ARM_CM3;\FreeRtos;..\User\inc;..\Libraries\CMSIS;..\Libraries\StartUp;D:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0\CMSIS\Include;..\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/src/: main.c gd32_it.c sys.c
  group Hardware
    ../Hardware/src/: usart.c IIC.c DMP.c MPU6050.c
  group GD32F10X_StdPeriph_Driver
    ../Libraries/GD32F10x_StdPeriph_Driver/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group GD32F10X
    ../Libraries/CMSIS/: system_gd32f10x.c
    ../Libraries/StartUp/: startup_gd32f10x_hd.s
  group FreeRtos
    ../FreeRtos/: list.c queue.c tasks.c timers.c
    ../FreeRtos/portable/RVDS/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
target Release (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: LynnFly
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
