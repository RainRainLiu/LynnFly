# Keil uVision project LynnFly.uvprojx, settings and files
target Lynn (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lynn +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DBG_PRINTF_OUT
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user\inc;..\LIB_STM32F10X\STM32F10x_StdPeriph_Driver\inc;..\user;..\LIB_STM32F10X\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Hardware\H;..\FreeRtos\include;..\FreeRtos;..\FreeRtos\portable\RVDS\ARM_CM3;..\APP\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../user/: main.c stm32f10x_it.c sys.c
  group Core
    ../LIB_STM32F10X/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIB_STM32F10X/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../LIB_STM32F10X/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Hardware
    ../Hardware/C/: IIC.c HMC5883L.c DMP.c MPU6050.c EXTI.c NRF24L01.c SPI.c Moto.c usart.c
  group App
    ../APP/src/: Posture.c
  group Lib
    ../LIB_STM32F10X/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Freertos
    ../FreeRtos/: queue.c tasks.c timers.c list.c
    ../FreeRtos/portable/RVDS/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
target LynnBLDR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Lynn +hex
  AfterMake: fromelf.exe --bincombined -o "..\output\@L_forBLDR.bin" "#L"
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DBG_PRINTF_OUT,USE_BLDR
  c include: as above
  memory RVCT4: ROM 0x8003600 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.0
